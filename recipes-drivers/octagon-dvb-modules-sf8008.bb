KV = "4.4.35"
SRCDATE = "20201207"

require octagon-dvb-modules-hisi.inc

SRC_URI[md5sum] = "ba4523ebeb313192c2181949fc00ef35"
SRC_URI[sha256sum] = "0590143ba42e7c8d75b835a09c16e540d68b0fc936bf873ab8b0eb635dcb521b"
